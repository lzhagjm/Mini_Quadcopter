# Keil uVision project MIni_Quadcopter.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MIni_Quadcopter
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4
  c include: ..\ALG_Lib;..\Application;..\BSP;..\ST_Lib\CMSIS;..\ST_Lib\STM32F10x_StdPeriph_Driver\inc;..\MPU_6050_DMP\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../ST_Lib/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../ST_Lib/CMSIS/: system_stm32f10x.c
  group ST_LIB
    ../ST_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group BSP
    ../BSP/: bsp_adc.c bsp_adc.h bsp_bluetooth.c bsp_bluetooth.h bsp_h_i2c.c bsp_h_i2c.h bsp_hollow_cup.c bsp_hollow_cup.h bsp_led.c bsp_led.h bsp_mpu6050.c bsp_mpu6050.h bsp_s_i2c.c bsp_s_i2c.h bsp_systick.c bsp_systick.h bsp_uc_debug.c bsp_uc_debug.h bsp_usart.c bsp_usart.h
  group ALG_Lib
    ../ALG_Lib/: FIR_lib.c FIR_lib.h math_lib.c math_lib.h pid_lib.c pid_lib.h
  group MPU_6050_DMP
    ../MPU_6050_DMP/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group Application
    ../Application/: core_run.c core_run.h main.c Scheduler.c Scheduler.h sys.c sys.h Task.c Task.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Doc
    ../Doc/: IO_Info.txt
